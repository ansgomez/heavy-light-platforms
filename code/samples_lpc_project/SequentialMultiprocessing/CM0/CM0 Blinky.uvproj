# Keil uVision project CM0 Blinky.uvproj, settings and files
target LPC4350 M0 RAM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: CM0_RAM
  AfterMake: fromelf --cadcombined --output="..\CM4\CM0_Image.c" ".\RAM\CM0_RAM.axf"
  c flags: Optim=1
  c define: CORE_M0 IPC_SLAVE IPC_CONFLICT MBX_IPC INT_IPC
  c misc: -D CORE_ID=2 -D PROFILING_TIMER=2
  c include: ..\..\Drivers\include;..\platform;.\;..\cm4;..\util;..\runtime
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ../../Core/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx_M0.s
  group lpc_swim
    ../util/: lcd.c xprintf.c
    ../platform/: lpc_colors.c lpc_fonts.c lpc_helvr10.c lpc_swim_font.c lpc_swim_image.c lpc_x6x13.c lpc_swim.c
  group lpc_43xx
    C:/nxp/Drivers/source/: lpc43xx_cgu.c lpc43xx_gpio.c lpc43xx_scu.c lpc43xx_timer.c lpc43xx_lcd.c
    ../platform/: LED_LPC43xx.c IS42S16400D.c
  group int_ipc
    ../platform/: slave_interrupt_callback.c
    ../../Drivers/source/: ipc_int.c
  group mailbox_ipc
    ../../Drivers/source/: ipc_buffer.c ipc_mbx.c
    ../platform/: slave_mbx_callbacks.c
    ../util/: IPCFunctions.c
    ./: m0_mbx_functions.c
  group runtime
    ../runtime/: profiling.c runtime.c statistics.c
  group tasks
    ../runtime/: tasks.c
  group main
    ./: main_M0.c
  group docs
    ./: Abstract.txt
