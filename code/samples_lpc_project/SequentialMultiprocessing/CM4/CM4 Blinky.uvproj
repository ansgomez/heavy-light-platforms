# Keil uVision project CM4 Blinky.uvproj, settings and files
target LPC4357 Flash (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky_Flash
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1
  c define: CORE_M4 IPC_MASTER IPC_CONFLICT MBX_IPC INT_IPC
  c misc: -D CORE_ID=1 -D PROFILING_TIMER=1
  c include: ..\..\Core\Device\NXP\LPC43xx\Include;..\..\Drivers\include;..\platform;.\;..\cm0;..\runtime;..\util
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup Code
    ../../Core/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx.s
    ../../Core/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
  group CM0_Image
    ./: CM0_Image.c
  group lpc_swim
    ../util/: lcd.c xprintf.c
    ../platform/: lpc_colors.c lpc_fonts.c lpc_helvr10.c lpc_swim.c lpc_swim_font.c lpc_swim_image.c lpc_x6x13.c
  group lpc_43xx
    ../platform/: IS42S16400D.c LED_LPC43xx.c
    ../../Drivers/source/: lpc43xx_cgu.c lpc43xx_gpio.c lpc43xx_scu.c lpc43xx_timer.c
    C:/nxp/Drivers/source/: lpc43xx_lcd.c
  group int_ipc
    ../platform/: master_interrupt_callback.c
    ../../Drivers/source/: ipc_int.c
  group mailbox_ipc
    ../../Drivers/source/: ipc_buffer.c ipc_mbx.c
    ../util/: IPCFunctions.c
    ../platform/: master_mbx_callbacks.c
    ./: m4_mbx_functions.c
  group runtime
    ../runtime/: profiling.c runtime.c statistics.c
  group tasks
    ../runtime/: tasks.c
  group main
    ./: main_M4.c
  group docs
    ./: Abstract.txt
